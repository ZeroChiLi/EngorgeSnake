# Keil uVision project EngorgeSnake.uvproj, settings and files
target Target 1 (MCS-51)
  device: M6759 Acer Labs
  cpu: IRAM(0-0xFF) CLOCK(40000000) XRAM (0-0xFF) MODDP2
  output: EngorgeSnake +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c InitConst.c InitConst.h InfraredInput.c InfraredInput.h KeyboardInput.c KeyboardInput.h Point.c Point.h Snake.c Snake.h Food.c Food.h MatrixLED.c MatrixLED.h
